Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-04-11T09:38:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190731_1515(x64) - Exporter 20.1.1.1 - Alternate UI 20.1.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 11 09:38:34 2023 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\75d9b366-a260-43a1-a148-2a21a13751da\70136d61-3dda-4fbd-987e-2354024b382a\ifc * Database version: 5507 * Database creation date: Tue Apr 11 09:38:33 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 11 09:38:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 11 09:38:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FL0656S-F_REVIT:S600 Freestanding Bath & Shower Mixer, FL0656S-F_REVIT:S600 Freestanding Bath & Shower Mixer:353756
In: Level 1
Material: Zink
Pset_DistributionFlowElementCommon - Reference: S600 Freestanding Bath & Shower Mixer; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
